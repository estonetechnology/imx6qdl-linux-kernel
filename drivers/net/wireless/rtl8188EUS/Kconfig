## drivers/net/wireless/rtl8188EUS/Kconfig
```kconfig
config RTL8188EU
	tristate "Realtek 8188ETV-NEW USB WiFi"
	depends on USB
	---help---
	  Help message of RTL8188EU
```
